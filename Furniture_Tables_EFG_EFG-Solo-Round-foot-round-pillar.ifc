Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Tables_EFG_EFG-Solo-Round-foot-round-pillar.ifc
Time: 2021-06-02T16:50:44
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: EFG Solo Round foot, round pillar
ePset_BIMobjectScript - Hight: Min; Colour on foot and pillar: Chrome; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): EFG Solo Round foot, round pillar; SKU (BO_prodsku): SOLO10; ManufacturName (BO_Manufac): EFG; BrandUrl (BO_brandurl): http://www.efg.se; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): Table; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 3/18/2020; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/efg/product/SOLO10; ProductDataUrl (BO_prodaturl): bimobject.com/efg/product/SOLO10; ProductUrl (BO_producturl): http://www.efg.info/en/Products/Workstations/Solo; ProductCertification (BO_prodcert): http://www.efg.info/en/Products/Workstations/Solo/?tab=Downloads; TechnicalDescription (BO_techcert): http://www.efg.info/en/Products/Chairs/EFG-Zoe/?tab=Downloads; MaterialMain (BO_mainmat): Metal; MaterialSecondary (BO_secmat): Wood; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Tables; BimObjectCategoryCode (BO_bocat_code): furniture-tables; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): JN; Uniclass14Description (BO_uniclass_1_4_desc): Furniture/Equipment; Uniclass2015Code (BO_uniclass2015_code): EF_40_30; Uniclass2015Description (BO_uniclass2015_desc): Furnishings; MasterFormat2014Code (BO_masterformat2014_code): 12 50 00; MasterFormat2014Description (BO_masterformat2014_name): Furniture; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA
